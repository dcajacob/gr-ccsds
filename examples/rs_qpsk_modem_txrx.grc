<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rs_qpsk_modem_txrx</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R</value></param>
<param><key>value</key><value>1/2.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>2**constel.bits_per_symbol()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>constel.bits_per_symbol()</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>corr_sequence</value></param>
<param><key>value</key><value>((-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>corr_sequence_nodiff</value></param>
<param><key>value</key><value>((-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>user_data_rate/R*R</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate_sps</value></param>
<param><key>value</key><value>data_rate/bps</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>decoder_variable</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[0133,0171]</value></param>
<param><key>rate</key><value>int(1/R)</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_rs_idle_frame</value></param>
<param><key>value</key><value>(29L, 166L, 101L, 78L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_rs_idle_frame_nodiff</value></param>
<param><key>value</key><value>(26L, 207L, 252L, 29L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_sync_word</value></param>
<param><key>comment</key><value>Last 6 bytes of the 8-byte 
encoded sync word.
(Invariant portion)</value></param>
<param><key>value</key><value>[57L, 167L, 60L, 49L, 128L, 82L]</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>encoder_variable</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>comment</key><value>Polynomials are often provided in octal.  
The blocks generally take decimals, though.
For example (171,133) =&gt; (121,91)</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[0133,0171]</value></param>
<param><key>rate</key><value>int(1/R)</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>fill</value></param>
<param><key>value</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>Add Fill Frames</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_idle_frame_trimmed</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed[i] for i in range(19175-1, 29405+1)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_idle_frame_trimmed_nodiff</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed_nodiff[i] for i in range(19175-1, 29405+1)]</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed</value></param>
<param><key>data</key><value>encoded_sync_word+[0]*6+encoded_sync_word+[255]*6+encoded_sync_word+[0]*6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_rx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed</value></param>
<param><key>data</key><value>list(encoded_rs_idle_frame)+[0]*223*5+list(encoded_rs_idle_frame)+[255]*223*5+list(encoded_rs_idle_frame)+[0]*223*5</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed_nodiff</value></param>
<param><key>data</key><value>list(encoded_rs_idle_frame_nodiff)+[0]*223*5+list(encoded_rs_idle_frame_nodiff)+[255]*223*5+list(encoded_rs_idle_frame_nodiff)+[0]*223*5</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_sync_word</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed[i] for i in range(555, 775)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps_rx), eb, 11*sps_rx*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>value</key><value>data_rate*sps_rx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>value</key><value>data_rate*sps_tx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_rx</value></param>
<param><key>value</key><value>4/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_tx</value></param>
<param><key>value</key><value>4/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>user_data_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>0.25e6*0+125e3/2</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_prefix + "/Downloads/blah.txt"</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.7</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>comment</key><value>Use for low SNR.  Not good when SNR is high.</value></param>
<param><key>const</key><value>50</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>1.0/pi</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0</value></param>
<param><key>const</key><value>1.0/20e3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0_0</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_1</value></param>
<param><key>const</key><value>1.0/pi</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>2</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>1115</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0_0</value></param>
<param><key>istunflag</key><value>True</value></param>
<param><key>ifn</key><value>tun0</value></param>
<param><key>mtu</key><value>mtu-2</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_1</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>ccsds_decapsulate_net</key>
<param><key>id</key><value>ccsds_decapsulate_net_0</value></param>
<param><key>disaggregate</key><value>False</value></param>
<param><key>mtu</key><value>1115</value></param>
<param><key>pad_byte</key><value>0x7E</value></param>
</block>
<block>
<key>ccsds_ccsds_decoder</key>
<param><key>id</key><value>ccsds_decoder</value></param>
<param><key>deinterleave</key><value>True</value></param>
<param><key>descramble</key><value>True</value></param>
<param><key>printing</key><value>False</value></param>
<param><key>rs_decode</key><value>True</value></param>
<param><key>threshold</key><value>4</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>ccsds_diff_decoder</key>
<param><key>id</key><value>ccsds_diff_decoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>ccsds_diff_encoder</key>
<param><key>id</key><value>ccsds_diff_encoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>ccsds_encapsulate_net</key>
<param><key>id</key><value>ccsds_encapsulate_net_0</value></param>
<param><key>aggregate</key><value>False</value></param>
<param><key>mtu</key><value>1115</value></param>
<param><key>pad_byte</key><value>0x7E</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>ccsds_ccsds_encoder</key>
<param><key>id</key><value>ccsds_encoder</value></param>
<param><key>asm_tail</key><value>False</value></param>
<param><key>idle_block_time</key><value>50</value></param>
<param><key>idle</key><value>False</value></param>
<param><key>type</key><value>message</value></param>
<param><key>interleave</key><value>True</value></param>
<param><key>len_tag_key</key><value>""</value></param>
<param><key>printing</key><value>False</value></param>
<param><key>rs_encode</key><value>True</value></param>
<param><key>scramble</key><value>True</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>ccsds_insert_idle_frame</key>
<param><key>id</key><value>ccsds_insert_idle_frame_0</value></param>
<param><key>modulated_vector</key><value>modulated_idle_frame_trimmed_nodiff</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>mu</key><value>eq_gain</value></param>
<param><key>modulus</key><value>1</value></param>
<param><key>num_taps</key><value>15</value></param>
<param><key>sps</key><value>2</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>constel</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>constel</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>eb</value></param>
<param><key>samples_per_symbol</key><value>sps_tx</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0</value></param>
<param><key>constellation</key><value>constel</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sps</key><value>sps_rx</value></param>
<param><key>symbols</key><value>modulated_sync_word</value></param>
<param><key>mark_delay</key><value>len(modulated_sync_word)-1-sps_tx/2</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0_0_0</value></param>
<param><key>sps</key><value>1</value></param>
<param><key>symbols</key><value>corr_sequence_nodiff</value></param>
<param><key>mark_delay</key><value>len(corr_sequence)-1</value></param>
<param><key>threshold</key><value>0.985*0+0.95</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>phase_bw</value></param>
<param><key>order</key><value>arity</value></param>
<param><key>use_snr</key><value>True</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0</value></param>
<param><key>comment</key><value>Resolves 90 deg ambiguity.  
Applies phase offset recovered 
by corr est block.  Don't try 
doing this before PFB CS</value></param>
<param><key>w</key><value>phase_bw</value></param>
<param><key>order</key><value>arity</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_0</value></param>
<param><key>rolloff</key><value>eb</value></param>
<param><key>w</key><value>phase_bw</value></param>
<param><key>filter_size</key><value>55</value></param>
<param><key>samps_per_sym</key><value>sps_rx</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>phase_bw</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>2</value></param>
<param><key>sps</key><value>sps_rx</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>eq_gain</value></param>
<param><key>label</key><value>Equalizer Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.01</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0</value></param>
<param><key>decoder_list</key><value>decoder_variable</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>fec_extended_encoder</key>
<param><key>id</key><value>fec_extended_encoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>encoder_list</key><value>encoder_variable</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_prefix</value></param>
<param><key>label</key><value>File Prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>expanduser('~')</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>he2pi_file_zeropad_source</key>
<param><key>id</key><value>he2pi_file_zeropad_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_prefix + "/Downloads/shakespeare.txt"</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>slp</key><value>1000</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>zeropad</key><value>int(samp_rate_tx)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>idle_block_time</value></param>
<param><key>label</key><value>Idle Block Time (ms)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_home</value></param>
<param><key>import</key><value>from os.path import expanduser</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_pi</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mtu</value></param>
<param><key>label</key><value>MTU</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1115</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phase_bw</value></param>
<param><key>label</key><value>Phase Bandwidth</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>6.28/100.0*0+0.05</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_rx</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label1</key><value>Received</value></param>
<param><key>label2</key><value>Post FLL BE</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>user_data_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"Rx Phase"</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>"|Correlation|^2"</value></param>
<param><key>name</key><value>"Correlation Outputs"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024*4</value></param>
<param><key>srate</key><value>samp_rate_tx</value></param>
<param><key>tr_delay</key><value>0.0005</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"corr_start"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"Rx Phase"</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>"|Correlation|^2"</value></param>
<param><key>name</key><value>"Correlation Outputs"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024*4</value></param>
<param><key>srate</key><value>samp_rate_tx</value></param>
<param><key>tr_delay</key><value>0.0005</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"corr_start"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>RX Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>415e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.999</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>label</key><value>TX Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>400e6</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(tx_freq, data_rate*2*0+1e6)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_tx</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>tx_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_tx</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_args</key><value>peak=0.7</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(rx_freq, samp_rate_rx*2)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>rx_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>user_data_rate</value></param>
<param><key>label</key><value>User Data Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.25e6*0+125e3/2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>tun_source</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>tun_source</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0_0_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>ccsds_diff_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>ccsds_encoder</sink_block_id><source_key>0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>digital_corr_est_cc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_0_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_1</source_block_id><sink_block_id>ccsds_diff_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_decapsulate_net_0</source_block_id><sink_block_id>blocks_tuntap_pdu_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ccsds_decoder</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ccsds_decoder</source_block_id><sink_block_id>ccsds_decapsulate_net_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_diff_decoder_0</source_block_id><sink_block_id>ccsds_decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_diff_encoder_0</source_block_id><sink_block_id>fec_extended_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_encapsulate_net_0</source_block_id><sink_block_id>ccsds_encoder</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_encoder</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_insert_idle_frame_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>ccsds_insert_idle_frame_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0</source_block_id><sink_block_id>fec_extended_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_arg_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0_0</source_block_id><sink_block_id>blocks_complex_to_arg_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>ccsds_diff_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>he2pi_file_zeropad_source_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>digital_fll_band_edge_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>ccsds_encapsulate_net_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
