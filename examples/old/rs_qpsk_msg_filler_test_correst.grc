<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rs_qpsk_msg_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R</value></param>
<param><key>value</key><value>1/2.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>2**constel.bits_per_symbol()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>constel.bits_per_symbol()</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>corr_sequence</value></param>
<param><key>value</key><value>((-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>corr_sequence_nodiff</value></param>
<param><key>value</key><value>((-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>user_data_rate/R*R</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate_sps</value></param>
<param><key>value</key><value>data_rate/bps</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>decoder_variable</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[0133,0171]</value></param>
<param><key>rate</key><value>int(1/R)</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>qtgui@0:4,1</value></param>
<param><key>label</key><value>Delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.35*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_rs_idle_frame</value></param>
<param><key>value</key><value>(29L, 166L, 101L, 78L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_rs_idle_frame_nodiff</value></param>
<param><key>value</key><value>(26L, 207L, 252L, 29L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_sync_word</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[57L, 167L, 60L, 49L, 128L, 82L]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_sync_word_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[57L, 167L, 60L, 49L, 128L, 82L]</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>encoder_variable</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>comment</key><value>Polynomials are often provided in octal.  
The blocks generally take decimals, though.
For example (171,133) =&gt; (121,91)</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[0133,0171]</value></param>
<param><key>rate</key><value>int(1/R)</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>eq_gain</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>gui_hint</key><value>qtgui@0:5,1</value></param>
<param><key>label</key><value>Equalizer: rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>frames_decoded</value></param>
<param><key>block_id</key><value>ccsds_decoder</value></param>
<param><key>function_name</key><value>num_frames_decoded</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>frames_received</value></param>
<param><key>block_id</key><value>ccsds_decoder</value></param>
<param><key>function_name</key><value>num_frames_received</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>frames_sent</value></param>
<param><key>block_id</key><value>ccsds_encoder</value></param>
<param><key>function_name</key><value>num_frames</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0.001</value></param>
<param><key>gui_hint</key><value>qtgui@0:3,2</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.1</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_idle_frame_trimmed</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed[i] for i in range(19175-1, 29405+1)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_idle_frame_trimmed_nodiff</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed_nodiff[i] for i in range(19175-1, 29405+1)]</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed</value></param>
<param><key>data</key><value>encoded_sync_word+[0]*6+encoded_sync_word+[255]*6+encoded_sync_word+[0]*6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_rx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed</value></param>
<param><key>data</key><value>list(encoded_rs_idle_frame)+[0]*223*5+list(encoded_rs_idle_frame)+[255]*223*5+list(encoded_rs_idle_frame)+[0]*223*5</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed_nodiff</value></param>
<param><key>data</key><value>list(encoded_rs_idle_frame_nodiff)+[0]*223*5+list(encoded_rs_idle_frame_nodiff)+[255]*223*5+list(encoded_rs_idle_frame_nodiff)+[0]*223*5</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_sync_word</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed[i] for i in range(555, 775)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_sync_word_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed[i] for i in range(555, 775)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_volt</value></param>
<param><key>value</key><value>0.005</value></param>
<param><key>gui_hint</key><value>qtgui@0:3,1</value></param>
<param><key>label</key><value>Channel: Noise Voltage</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1.5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_bw</value></param>
<param><key>value</key><value>2*pi/100.0*0+0.05</value></param>
<param><key>gui_hint</key><value>qtgui@0:5,2</value></param>
<param><key>label</key><value>Phase: Bandwidth</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_offset</value></param>
<param><key>value</key><value>pi/2.</value></param>
<param><key>gui_hint</key><value>qtgui@1:1,2,1,2</value></param>
<param><key>label</key><value>Phase Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-pi</value></param>
<param><key>step</key><value>2*pi/100.</value></param>
<param><key>stop</key><value>pi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps_rx), eb, 11*sps_rx*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>value</key><value>data_rate*sps_rx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>value</key><value>data_rate*sps_tx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_rx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_tx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>subframes_decoded</value></param>
<param><key>block_id</key><value>ccsds_decoder</value></param>
<param><key>function_name</key><value>num_subframes_decoded</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>value</key><value>[0x1a, 0xcf, 0xfc, 0x1d]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>time_offset</value></param>
<param><key>value</key><value>1.00</value></param>
<param><key>gui_hint</key><value>qtgui@0:4,2</value></param>
<param><key>label</key><value>Timing Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.999</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>1.001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>user_data_rate</value></param>
<param><key>value</key><value>0.25e6*0+125e3*2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>frames_sent</value></param>
<param><key>gui_hint</key><value>qtgui@2:0,0</value></param>
<param><key>label</key><value>frames sent</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1</value></param>
<param><key>value</key><value>frames_received</value></param>
<param><key>gui_hint</key><value>qtgui@2:1,0</value></param>
<param><key>label</key><value>frames received</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_0</value></param>
<param><key>value</key><value>frames_decoded</value></param>
<param><key>gui_hint</key><value>qtgui@2:0,1</value></param>
<param><key>label</key><value>frames decoded</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_0_0</value></param>
<param><key>value</key><value>subframes_decoded</value></param>
<param><key>gui_hint</key><value>qtgui@2:1,1</value></param>
<param><key>label</key><value>subframes decoded</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0_1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_1</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_2</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
<param><key>comment</key><value>This ought to simulate spectral inversion...</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0</value></param>
<param><key>comment</key><value>Delay with 0 seems to deadlock 
in some situations.  Copy helped.</value></param>
<param><key>enabled</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>delay</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_prefix + "/Downloads/blah.txt"</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/dan/Downloads/shakespeare.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>100</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1/pi</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>1.0/pi</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>comment</key><value>Apply a fixed phase offset.</value></param>
<param><key>const</key><value>np.exp(1j*phase_offset)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>223*5+1</value></param>
<param><key>minsize</key><value>223*5*0+32</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>2</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>3.14/160</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>int(samp_rate_rx*0.5)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>1115</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>filter</key><value>"phase_est"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate_tx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>samp_rate_rx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_1</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_1_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>modulated_preamble_untrimmed_nodiff</value></param>
</block>
<block>
<key>ccsds_decapsulate_net</key>
<param><key>id</key><value>ccsds_decapsulate_net_0</value></param>
<param><key>disaggregate</key><value>False</value></param>
<param><key>mtu</key><value>1115</value></param>
<param><key>pad_byte</key><value>0x7E</value></param>
</block>
<block>
<key>ccsds_ccsds_decoder</key>
<param><key>id</key><value>ccsds_decoder</value></param>
<param><key>deinterleave</key><value>True</value></param>
<param><key>descramble</key><value>True</value></param>
<param><key>printing</key><value>False</value></param>
<param><key>rs_decode</key><value>True</value></param>
<param><key>threshold</key><value>4</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>ccsds_diff_decoder</key>
<param><key>id</key><value>ccsds_diff_decoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>ccsds_diff_encoder</key>
<param><key>id</key><value>ccsds_diff_encoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>ccsds_encapsulate_net</key>
<param><key>id</key><value>ccsds_encapsulate_net_0</value></param>
<param><key>aggregate</key><value>False</value></param>
<param><key>mtu</key><value>1115</value></param>
<param><key>pad_byte</key><value>0x7E</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>ccsds_ccsds_encoder</key>
<param><key>id</key><value>ccsds_encoder</value></param>
<param><key>asm_tail</key><value>False</value></param>
<param><key>idle_block_time</key><value>50</value></param>
<param><key>idle</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>interleave</key><value>True</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>printing</key><value>False</value></param>
<param><key>rs_encode</key><value>True</value></param>
<param><key>scramble</key><value>True</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>ccsds_insert_idle_frame</key>
<param><key>id</key><value>ccsds_insert_idle_frame_0</value></param>
<param><key>modulated_vector</key><value>modulated_idle_frame_trimmed_nodiff</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>time_offset</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>noise_voltage</key><value>noise_volt</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>mu</key><value>eq_gain</value></param>
<param><key>modulus</key><value>1</value></param>
<param><key>num_taps</key><value>15</value></param>
<param><key>sps</key><value>2</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>constel</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>constel</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>eb</value></param>
<param><key>samples_per_symbol</key><value>sps_tx</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0</value></param>
<param><key>comment</key><value>Outputs 2 floats for every 
1 symbol input for QPSK.</value></param>
<param><key>constellation</key><value>constel</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0_0</value></param>
<param><key>sps</key><value>1</value></param>
<param><key>symbols</key><value>corr_sequence_nodiff</value></param>
<param><key>mark_delay</key><value>len(corr_sequence)-1</value></param>
<param><key>threshold</key><value>0.985*0+0.95</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>phase_bw</value></param>
<param><key>order</key><value>arity</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0</value></param>
<param><key>w</key><value>phase_bw*0.1*0</value></param>
<param><key>order</key><value>arity</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_0</value></param>
<param><key>rolloff</key><value>eb</value></param>
<param><key>w</key><value>2*3.14/100.0*0+phase_bw</value></param>
<param><key>filter_size</key><value>45*0+55+len(rrc_taps)/2/32*0</value></param>
<param><key>samps_per_sym</key><value>sps_rx</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/100.0*0+phase_bw</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>2</value></param>
<param><key>sps</key><value>sps_rx</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>digital_probe_mpsk_snr_est_c</key>
<param><key>id</key><value>digital_probe_mpsk_snr_est_c_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>msg_nsamples</key><value>int(samp_rate_tx)</value></param>
<param><key>type</key><value>0</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0</value></param>
<param><key>decoder_list</key><value>decoder_variable</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>fec_extended_encoder</key>
<param><key>id</key><value>fec_extended_encoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>encoder_list</key><value>encoder_variable</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_prefix</value></param>
<param><key>label</key><value>File Prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>expanduser('~')</value></param>
</block>
<block>
<key>he2pi_file_zeropad_source</key>
<param><key>id</key><value>he2pi_file_zeropad_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_prefix + "/Downloads/shakespeare.txt"</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>slp</key><value>1000</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>zeropad</key><value>int(samp_rate_tx)</value></param>
</block>
<block>
<key>he2pi_precisiontiming_pt_resampler</key>
<param><key>id</key><value>he2pi_precisiontiming_pt_resampler_0</value></param>
<param><key>desired_path_length</key><value>32</value></param>
<param><key>input_sample_rate</key><value>int(samp_rate_tx)</value></param>
<param><key>output_sample_rate</key><value>int(samp_rate_rx)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_home</value></param>
<param><key>import</key><value>from os.path import expanduser</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_pi</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>qtgui</value></param>
<param><key>gui_hint</key><value>0,0,1,4</value></param>
<param><key>label0</key><value>fft</value></param>
<param><key>label1</key><value>const</value></param>
<param><key>label2</key><value>stats</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>gui_hint</key><value>qtgui@1:2,2</value></param>
<param><key>style1</key><value>1</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1_0</value></param>
<param><key>gui_hint</key><value>qtgui@1:2,1</value></param>
<param><key>style1</key><value>1</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_tx</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>qtgui@0:1,1,1,2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate_rx</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Constellation Decoder Out"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>user_data_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>qtgui@0:2,1,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>TX Bits</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>CC Bits</value></param>
<param><key>name</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>500</value></param>
<param><key>srate</key><value>user_data_rate</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_tag</key><value>"packet_len"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>0</value></param>
<param><key>size</key><value>len(modulated_preamble_untrimmed)</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>len(modulated_preamble_untrimmed)</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"Rx Phase"</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>"|Correlation|^2"</value></param>
<param><key>name</key><value>"Correlation Outputs"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024*4</value></param>
<param><key>srate</key><value>samp_rate_tx</value></param>
<param><key>tr_delay</key><value>0.0005</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"corr_start"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>bits_out</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>bits_in</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>bits_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>bits_in</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_conjugate_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_random_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>digital_fll_band_edge_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0_0_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>ccsds_encoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>ccsds_encapsulate_net_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>ccsds_diff_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>ccsds_encoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>he2pi_precisiontiming_pt_resampler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>blocks_complex_to_arg_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_1</source_block_id><sink_block_id>ccsds_diff_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_1_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_decapsulate_net_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ccsds_decoder</source_block_id><sink_block_id>ccsds_decapsulate_net_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_diff_decoder_0</source_block_id><sink_block_id>ccsds_decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_diff_encoder_0</source_block_id><sink_block_id>fec_extended_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_encapsulate_net_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ccsds_encoder</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_insert_idle_frame_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>ccsds_insert_idle_frame_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0</source_block_id><sink_block_id>fec_extended_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_arg_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>blocks_tag_debug_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_corr_est_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>digital_probe_mpsk_snr_est_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_probe_mpsk_snr_est_c_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>snr</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>ccsds_diff_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>he2pi_file_zeropad_source_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>he2pi_file_zeropad_source_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>he2pi_precisiontiming_pt_resampler_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
