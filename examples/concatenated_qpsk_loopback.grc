<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>concatenated_qpsk_loopback</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R</value></param>
<param><key>value</key><value>1/2.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>2**constel.bits_per_symbol()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>constel.bits_per_symbol()</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>corr_sequence</value></param>
<param><key>value</key><value>((0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>corr_sequence_nodiff</value></param>
<param><key>value</key><value>((-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j))</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>decoder_variable</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>0</value></param>
<param><key>framebits</key><value>1279*8*0+80</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[epy_tools.reverse_bits(0171), -epy_tools.reverse_bits(0133)]</value></param>
<param><key>rate</key><value>int(1/R)</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>qtgui@0:4,1</value></param>
<param><key>label</key><value>Delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.35*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>enc_idle_frame_len</value></param>
<param><key>value</key><value>len(encoded_concat_idle_frame_nodiff)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame</value></param>
<param><key>value</key><value>encoded_concat_idle_frame_raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame_nodiff</value></param>
<param><key>value</key><value>encoded_concat_idle_frame_nodiff_raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame_nodiff_raw</value></param>
<param><key>value</key><value>(222, 58, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 46, 28, 13, 131, 30, 166, 44, 110)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame_raw</value></param>
<param><key>value</key><value>(14, 215, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 156, 151, 46, 123, 178, 229, 229, 94, 92, 156, 9, 203, 187, 11, 185, 85, 201, 87, 0, 187, 2, 192, 149, 194, 112, 176, 178, 236, 156, 158, 87, 187, 185, 194, 85, 87, 178, 192, 2, 94, 112, 2, 201, 236, 2, 123, 151, 2, 229, 114, 194, 92, 46, 114, 203, 37, 238, 121, 236, 149, 231, 151, 176, 158, 114, 92, 185, 238, 203, 151, 149, 121, 114, 112, 39, 46, 236, 46, 229, 87, 37, 92, 2, 236, 11, 2, 87, 9, 194, 194, 203, 178, 114, 121, 94, 238, 231, 9, 85, 94, 203, 0, 9, 121, 192, 11, 39, 176, 9, 238, 92, 11, 149, 203, 9, 112, 185, 203, 44, 151, 185, 231, 178, 87, 158, 94, 194, 121, 201, 114, 231, 187, 46, 94, 85, 229, 201, 192, 156, 187, 176, 187, 149, 92, 149, 112, 11, 176, 44, 9, 92, 39, 11, 11, 46, 201, 201, 229, 123, 187, 156, 37, 85, 123, 44, 0, 37, 231, 0, 44, 158, 192, 39, 185, 112, 46, 87, 44, 37, 194, 231, 44, 178, 94, 231, 158, 201, 94, 121, 123, 9, 231, 37, 203, 158, 236, 185, 121, 87, 151, 39, 2, 114, 238, 194, 238, 85, 114, 85, 192, 46, 192, 176, 37, 112, 156, 44, 44, 187, 39, 39, 149, 238, 238, 112, 149, 85, 236, 176, 0, 151, 156, 0, 178, 123, 0, 158, 229, 192, 185, 92, 176, 151, 11, 156, 178, 201, 123, 158, 123, 37, 121, 229, 236, 39, 91, 166, 107, 48, 31, 83, 29, 181)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_sync_word</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>(246L, 168L, 195L, 206L, 128L, 109L)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_sync_word_nodiff</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>(73L, 194L, 79L, 242L, 104L, 107L)</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>encoder_variable</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>comment</key><value>Polynomials are often provided in octal.  
The blocks generally take decimals, though.
For example (171,133) =&gt; (121,91)

Polynomials are read as if the shift register
goes from right to left... e.g.,
output &lt;- [convolve 1001111] &lt;- input
corresponds to the polynomial
0x4f=79d=0117.

This is equivalent but "bit-reversed" from
the left to right:
input -&gt; [convolve 1111001] -&gt; output
which woud be 0x79=121d=0171.</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>1279*8*0+80</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[epy_tools.reverse_bits(0171), -epy_tools.reverse_bits(0133)]</value></param>
<param><key>rate</key><value>int(1/R)</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>eq_gain</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>gui_hint</key><value>qtgui@0:5,1</value></param>
<param><key>label</key><value>Equalizer: rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fillframes_decoded</value></param>
<param><key>block_id</key><value>ccsds_decoder</value></param>
<param><key>function_name</key><value>num_fillframes_decoded</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fillframes_sent</value></param>
<param><key>block_id</key><value>ccsds_insert_idle_frame</value></param>
<param><key>function_name</key><value>num_fillframes_added</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>frames_decoded</value></param>
<param><key>block_id</key><value>ccsds_decoder</value></param>
<param><key>function_name</key><value>num_frames_decoded</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>frames_received</value></param>
<param><key>block_id</key><value>ccsds_decoder</value></param>
<param><key>function_name</key><value>num_frames_received</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>frames_sent</value></param>
<param><key>block_id</key><value>ccsds_encoder</value></param>
<param><key>function_name</key><value>num_frames</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0.001</value></param>
<param><key>gui_hint</key><value>qtgui@0:3,2</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.1</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>idle_frame_shift</value></param>
<param><key>value</key><value>20+2-22</value></param>
<param><key>gui_hint</key><value>qtgui@0:6,0,1,2</value></param>
<param><key>label</key><value>Idle Frame Shift</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-len(sync_word)*8</value></param>
<param><key>step</key><value>2</value></param>
<param><key>stop</key><value>len(sync_word)*8</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod_len</value></param>
<param><key>value</key><value>len(modulated_idle_frame_trimmed_nodiff)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_idle_frame_trimmed</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed[i] for i in range(enc_idle_frame_len*sps_tx/bps*8+idle_frame_shift, 2*enc_idle_frame_len*sps_tx/bps*8+idle_frame_shift)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_idle_frame_trimmed_nodiff</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed_nodiff[i] for i in range(enc_idle_frame_len*sps_tx/bps*8+idle_frame_shift, 2*enc_idle_frame_len*sps_tx/bps*8+idle_frame_shift)]</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed</value></param>
<param><key>data</key><value>encoded_sync_word+[0]*6+encoded_sync_word+[255]*6+encoded_sync_word+[0]*6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_rx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed</value></param>
<param><key>comment</key><value>Packed bytes get modulated.
Samples come out.
Since we're QPSK, you get
8*sps/bps out.

This modulator delays the
center of the first symbol
by 22 samples.</value></param>
<param><key>data</key><value>list(encoded_concat_idle_frame)*3</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed_nodiff</value></param>
<param><key>data</key><value>list(encoded_concat_idle_frame_nodiff)*3</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_sync_word</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed[i] for i in range(555, 775)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_sync_word_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed[i] for i in range(555, 775)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_volt</value></param>
<param><key>value</key><value>0.005</value></param>
<param><key>gui_hint</key><value>qtgui@0:3,1</value></param>
<param><key>label</key><value>Channel: Noise Voltage</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pad</value></param>
<param><key>value</key><value>[0]*223*5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_bw</value></param>
<param><key>value</key><value>2*pi/100.0*0+0.05</value></param>
<param><key>gui_hint</key><value>qtgui@0:5,2</value></param>
<param><key>label</key><value>Phase: Bandwidth</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_offset</value></param>
<param><key>value</key><value>pi/2.</value></param>
<param><key>gui_hint</key><value>qtgui@1:1,2,1,2</value></param>
<param><key>label</key><value>Phase Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-pi</value></param>
<param><key>step</key><value>2*pi/100.</value></param>
<param><key>stop</key><value>pi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps_rx), eb, 11*sps_rx*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_data_rate</value></param>
<param><key>value</key><value>rx_user_data_rate/R</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_data_rate_sps</value></param>
<param><key>value</key><value>rx_data_rate/bps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>value</key><value>rx_data_rate_sps*sps_rx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>value</key><value>tx_data_rate_sps*sps_tx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_rx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_tx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>subframes_decoded</value></param>
<param><key>block_id</key><value>ccsds_decoder</value></param>
<param><key>function_name</key><value>num_subframes_decoded</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>value</key><value>[0x1a, 0xcf, 0xfc, 0x1d]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>time_offset</value></param>
<param><key>value</key><value>1.00</value></param>
<param><key>gui_hint</key><value>qtgui@0:4,2</value></param>
<param><key>label</key><value>Timing Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.999</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>1.001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_data_rate</value></param>
<param><key>value</key><value>tx_user_data_rate/R</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_data_rate_sps</value></param>
<param><key>value</key><value>tx_data_rate/bps</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_0</value></param>
<param><key>block_id</key><value>blocks_probe_signal_vx_0_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.5</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>variable_qtgui_entry_0_0</value></param>
<param><key>value</key><value>variable_function_probe_0_0</value></param>
<param><key>label</key><value>Debug</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>frames_sent</value></param>
<param><key>gui_hint</key><value>qtgui@2:0,0</value></param>
<param><key>label</key><value>frames sent</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1</value></param>
<param><key>value</key><value>frames_received</value></param>
<param><key>gui_hint</key><value>qtgui@2:1,0</value></param>
<param><key>label</key><value>frames received</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_0</value></param>
<param><key>value</key><value>frames_decoded</value></param>
<param><key>gui_hint</key><value>qtgui@2:0,1</value></param>
<param><key>label</key><value>frames decoded</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_0_0</value></param>
<param><key>value</key><value>subframes_decoded</value></param>
<param><key>gui_hint</key><value>qtgui@2:1,1</value></param>
<param><key>label</key><value>subframes decoded</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_1</value></param>
<param><key>value</key><value>frames_received-frames_decoded</value></param>
<param><key>label</key><value>frames detected minus decoded</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_1_0</value></param>
<param><key>value</key><value>fillframes_sent - fillframes_decoded</value></param>
<param><key>label</key><value>fill frames sent minus received</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_1_0_0</value></param>
<param><key>value</key><value>fillframes_sent</value></param>
<param><key>gui_hint</key><value>qtgui@2:3,0</value></param>
<param><key>label</key><value>fill frames sent</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_1_0_0_0</value></param>
<param><key>value</key><value>fillframes_decoded</value></param>
<param><key>gui_hint</key><value>qtgui@2:3,1</value></param>
<param><key>label</key><value>fill frames received</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_1_0_1</value></param>
<param><key>value</key><value>frames_sent + fillframes_sent - frames_decoded</value></param>
<param><key>label</key><value>all frames sent - frames decoded</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_1</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_2</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
<param><key>comment</key><value>This ought to simulate spectral inversion...</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0</value></param>
<param><key>comment</key><value>Delay with 0 seems to deadlock 
in some situations.  Copy helped.</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>enabled</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>delay</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_prefix + "/Downloads/blah.txt"</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/dan/Downloads/shakespeare.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>1279*16*10</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>1279*8*2+idle_frame_shift</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mean</key><value>10</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>std</key><value>10</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_1</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>100</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1/pi</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>1.0/pi</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>comment</key><value>Apply a fixed phase offset.</value></param>
<param><key>const</key><value>np.exp(1j*phase_offset)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>2</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>blocks_probe_signal_vx_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1279*2/2</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>(223*5-2)+84*0</value></param>
<param><key>minsize</key><value>(223*5-2)+84*0</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>2</value></param>
<param><key>l</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>phase_inc</key><value>3.14/160</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>int(samp_rate_rx*0.5)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>1*0+(704+1)/2*sps_tx-(316+32)*sps_tx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>1115</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1279*2/2</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>filter</key><value>"phase_est"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate_tx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>samp_rate_rx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1_0</value></param>
<param><key>samples_per_second</key><value>samp_rate_rx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_1</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>modulated_preamble_untrimmed_nodiff</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>modulated_idle_frame_trimmed_nodiff</value></param>
</block>
<block>
<key>ccsds_decapsulate_net</key>
<param><key>id</key><value>ccsds_decapsulate_net_0</value></param>
<param><key>disaggregate</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mtu</key><value>1115</value></param>
<param><key>pad_byte</key><value>0x7E</value></param>
</block>
<block>
<key>ccsds_ccsds_decoder</key>
<param><key>id</key><value>ccsds_decoder</value></param>
<param><key>deinterleave</key><value>True</value></param>
<param><key>descramble</key><value>True</value></param>
<param><key>printing</key><value>False</value></param>
<param><key>rs_decode</key><value>True</value></param>
<param><key>threshold</key><value>4</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>ccsds_diff_decoder</key>
<param><key>id</key><value>ccsds_diff_decoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>ccsds_diff_encoder</key>
<param><key>id</key><value>ccsds_diff_encoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>ccsds_encapsulate_net</key>
<param><key>id</key><value>ccsds_encapsulate_net_0</value></param>
<param><key>aggregate</key><value>False</value></param>
<param><key>mtu</key><value>1115</value></param>
<param><key>pad_byte</key><value>0x7E</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>ccsds_ccsds_encoder</key>
<param><key>id</key><value>ccsds_encoder</value></param>
<param><key>asm_tail</key><value>True</value></param>
<param><key>idle_block_time</key><value>50</value></param>
<param><key>idle</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>interleave</key><value>True</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>printing</key><value>False</value></param>
<param><key>rs_encode</key><value>True</value></param>
<param><key>scramble</key><value>True</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>ccsds_insert_idle_frame</key>
<param><key>id</key><value>ccsds_insert_idle_frame</value></param>
<param><key>modulated_vector</key><value>modulated_idle_frame_trimmed_nodiff</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>time_offset</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>noise_voltage</key><value>noise_volt</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>constel.points()</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>mu</key><value>eq_gain</value></param>
<param><key>modulus</key><value>1</value></param>
<param><key>num_taps</key><value>15</value></param>
<param><key>sps</key><value>2</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>constel</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>constel</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>eb</value></param>
<param><key>samples_per_symbol</key><value>sps_tx</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0</value></param>
<param><key>comment</key><value>Outputs 2 floats for every 
1 symbol input for QPSK.</value></param>
<param><key>constellation</key><value>constel</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0_0</value></param>
<param><key>sps</key><value>1</value></param>
<param><key>symbols</key><value>corr_sequence_nodiff</value></param>
<param><key>mark_delay</key><value>len(corr_sequence)-1</value></param>
<param><key>threshold</key><value>0.985*0+0.985</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_bb</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0_0_0</value></param>
<param><key>access_code</key><value>''.join([bin(x)[2:].zfill(8) for x in sync_word])</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0</value></param>
<param><key>access_code</key><value>''.join([bin(x)[2:].zfill(8) for x in sync_word])</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>phase_bw</value></param>
<param><key>order</key><value>arity</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0</value></param>
<param><key>w</key><value>phase_bw*0.1*0</value></param>
<param><key>order</key><value>arity</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_0</value></param>
<param><key>rolloff</key><value>eb</value></param>
<param><key>w</key><value>2*3.14/100.0*0+phase_bw</value></param>
<param><key>filter_size</key><value>45*0+55+len(rrc_taps)/2/32*0</value></param>
<param><key>samps_per_sym</key><value>sps_rx</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/100.0*0+phase_bw</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>2</value></param>
<param><key>sps</key><value>sps_rx</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>digital_probe_mpsk_snr_est_c</key>
<param><key>id</key><value>digital_probe_mpsk_snr_est_c_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>msg_nsamples</key><value>int(samp_rate_tx)</value></param>
<param><key>type</key><value>0</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>epy_tools</value></param>
<param><key>source_code</key><value>
def reverse_bits(x):
    return int(bin(x)[2:][::-1], base=2)

</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0</value></param>
<param><key>decoder_list</key><value>decoder_variable</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>fec_extended_encoder</key>
<param><key>id</key><value>fec_extended_encoder_0</value></param>
<param><key>encoder_list</key><value>encoder_variable</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_delay</key><value>15</value></param>
<param><key>taps</key><value>firdes.root_raised_cosine(1, 2, 1, 0.5, 31)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_prefix</value></param>
<param><key>label</key><value>File Prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>expanduser('~')</value></param>
</block>
<block>
<key>he2pi_file_zeropad_source</key>
<param><key>id</key><value>he2pi_file_zeropad_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_prefix + "/Downloads/shakespeare.txt"</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>slp</key><value>1000</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>zeropad</key><value>int(samp_rate_tx)</value></param>
</block>
<block>
<key>he2pi_precisiontiming_pt_resampler</key>
<param><key>id</key><value>he2pi_precisiontiming_pt_resampler_0</value></param>
<param><key>desired_path_length</key><value>32</value></param>
<param><key>input_sample_rate</key><value>int(samp_rate_tx)</value></param>
<param><key>output_sample_rate</key><value>int(samp_rate_rx)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_home</value></param>
<param><key>import</key><value>from os.path import expanduser</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_pi</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>qtgui</value></param>
<param><key>gui_hint</key><value>0,0,1,4</value></param>
<param><key>label0</key><value>fft</value></param>
<param><key>label1</key><value>const</value></param>
<param><key>label2</key><value>stats</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>gui_hint</key><value>qtgui@1:2,2</value></param>
<param><key>style1</key><value>1</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1_0</value></param>
<param><key>gui_hint</key><value>qtgui@1:2,1</value></param>
<param><key>style1</key><value>1</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_tx</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>qtgui@0:1,1,1,2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate_rx</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Constellation Decoder Out"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>user_data_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>qtgui@0:2,1,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>TX Bits</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>CC Bits</value></param>
<param><key>name</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>500</value></param>
<param><key>srate</key><value>user_data_rate</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_tag</key><value>"packet_len"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>10232*2</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>0</value></param>
<param><key>size</key><value>len(modulated_preamble_untrimmed)</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>len(modulated_preamble_untrimmed)</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0_1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>0</value></param>
<param><key>size</key><value>len(modulated_idle_frame_trimmed_nodiff)</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1279*16*10</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>name</key><value>"Laddy Frick'n Dah"</value></param>
<param><key>size</key><value>1279*8*4</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"Rx Phase"</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>"|Correlation|^2"</value></param>
<param><key>name</key><value>"Correlation Outputs"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024*4</value></param>
<param><key>srate</key><value>samp_rate_tx</value></param>
<param><key>tr_delay</key><value>0.0005</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"corr_start"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1000</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_0_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"Rx Phase"</value></param>
<param><key>name</key><value>"Correlation Outputs"</value></param>
<param><key>size</key><value>len(modulated_idle_frame_trimmed_nodiff)/bps</value></param>
<param><key>srate</key><value>samp_rate_tx</value></param>
<param><key>tr_delay</key><value>0.0005</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_tag</key><value>"corr_start"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>ymax</key><value>1000</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Data + Filler Packets"</value></param>
<param><key>size</key><value>1279*2*8*2/2</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Data Packets"</value></param>
<param><key>size</key><value>1279*2*8*2/2</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"First Packet"</value></param>
<param><key>size</key><value>1279*2*8+idle_frame_shift</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_user_data_rate</value></param>
<param><key>label</key><value>RX Data Rate</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_user_data_rate</value></param>
<param><key>label</key><value>TX Data Rate</value></param>
<param><key>short_id</key><value>t</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>bits_out</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>bits_in</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>bits_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>bits_in</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_conjugate_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_1</source_block_id><sink_block_id>qtgui_time_sink_x_3_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_random_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_random_1</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>he2pi_precisiontiming_pt_resampler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0_0_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_1</source_block_id><sink_block_id>blocks_char_to_float_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>ccsds_encoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>ccsds_encapsulate_net_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>ccsds_diff_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_1_0</source_block_id><sink_block_id>ccsds_insert_idle_frame</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>ccsds_encoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_probe_signal_vx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>blocks_complex_to_arg_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_1</source_block_id><sink_block_id>ccsds_diff_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_1_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_throttle_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_decapsulate_net_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ccsds_decoder</source_block_id><sink_block_id>ccsds_decapsulate_net_0</sink_block_id><source_key>out</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_diff_decoder_0</source_block_id><sink_block_id>ccsds_decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_diff_decoder_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_diff_decoder_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_diff_encoder_0</source_block_id><sink_block_id>fec_extended_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_encapsulate_net_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ccsds_encoder</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_insert_idle_frame</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_insert_idle_frame</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_insert_idle_frame</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_insert_idle_frame</source_block_id><sink_block_id>qtgui_time_sink_x_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>blocks_head_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>blocks_skiphead_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>ccsds_insert_idle_frame</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>qtgui_time_sink_x_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0</source_block_id><sink_block_id>fec_extended_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_arg_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>blocks_tag_debug_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_corr_est_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>digital_probe_mpsk_snr_est_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_probe_mpsk_snr_est_c_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>snr</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>ccsds_diff_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>blocks_skiphead_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>he2pi_file_zeropad_source_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>he2pi_file_zeropad_source_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>he2pi_precisiontiming_pt_resampler_0</source_block_id><sink_block_id>digital_fll_band_edge_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
