<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>concatenated_qpsk_modem_txrx_gui</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R</value></param>
<param><key>value</key><value>1/2.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>2**constel.bits_per_symbol()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>constel.bits_per_symbol()</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>corr_sequence</value></param>
<param><key>value</key><value>((-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>corr_sequence_nodiff</value></param>
<param><key>value</key><value>((0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>user_data_rate/R</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate_sps</value></param>
<param><key>value</key><value>data_rate/bps</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>decoder_variable</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[0133,0171]</value></param>
<param><key>rate</key><value>int(1/R)</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>enc_idle_frame_len</value></param>
<param><key>value</key><value>len(encoded_concat_idle_frame_nodiff)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame</value></param>
<param><key>comment</key><value>Trim the first ASM off</value></param>
<param><key>value</key><value>encoded_concat_idle_frame_raw[4*2:]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame_nodiff</value></param>
<param><key>comment</key><value>Trim the first ASM off</value></param>
<param><key>value</key><value>encoded_concat_idle_frame_nodiff_raw[4*2:]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame_nodiff_raw</value></param>
<param><key>value</key><value>(3L, 98L, 74L, 61L, 79L, 242L, 152L, 87L, 2L, 63L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 175L, 98L, 74L, 61L, 79L, 242L, 152L, 87L)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame_raw</value></param>
<param><key>value</key><value>(3L, 87L, 57L, 167L, 60L, 49L, 128L, 82L, 32L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 15L, 155L, 245L, 107L, 240L, 253L, 76L, 158L)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_sync_word</value></param>
<param><key>comment</key><value>Last 6 bytes of the 8-byte 
encoded sync word.
(Invariant portion)</value></param>
<param><key>value</key><value>[57L, 167L, 60L, 49L, 128L, 82L]</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>encoder_variable</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>comment</key><value>Polynomials are often provided in octal.  
The blocks generally take decimals, though.
For example (171,133) =&gt; (121,91)</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[0133,0171]</value></param>
<param><key>rate</key><value>int(1/R)</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>idle_frame_shift</value></param>
<param><key>value</key><value>-12+8+4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>6,0,1,2</value></param>
<param><key>label</key><value>Idle Frame Shift</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-64</value></param>
<param><key>step</key><value>2</value></param>
<param><key>stop</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>idle_frame_shift</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>-12+8+4-4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_idle_frame_trimmed</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed[i] for i in range(len(pad)*8+24, len(pad)*8+24+enc_idle_frame_len*8+1-1)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_idle_frame_trimmed_nodiff</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed_nodiff[i] for i in range(len(pad)*8+24, len(pad)*8+24+enc_idle_frame_len*8+1-1)]</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed</value></param>
<param><key>data</key><value>encoded_sync_word+[0]*6+encoded_sync_word+[255]*6+encoded_sync_word+[0]*6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_rx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed</value></param>
<param><key>comment</key><value>Packed bytes get modulated.
Samples come out.
Since we're QPSK, you get
8*sps/bps out.</value></param>
<param><key>data</key><value>pad + list(encoded_concat_idle_frame) + pad</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed_nodiff</value></param>
<param><key>data</key><value>pad + list(encoded_concat_idle_frame_nodiff) + pad</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_sync_word</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed[i] for i in range(555, 775)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pad</value></param>
<param><key>value</key><value>[0]*223*5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps_rx), eb, 11*sps_rx*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>value</key><value>data_rate*sps_rx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>value</key><value>data_rate*sps_tx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_rx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_tx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>user_data_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>0.25e6*0+125e3/2</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_1_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_prefix + "/Downloads/blah.txt"</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>comment</key><value>Use for low SNR.  Not good when SNR is high.</value></param>
<param><key>const</key><value>50</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>1.0/pi</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0</value></param>
<param><key>const</key><value>1.0/20e3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0_0</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_1</value></param>
<param><key>const</key><value>1.0/pi</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>(1*0+(704+1)/2*sps_tx+(10232-316-32)*sps_tx)*0+12</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_1</value></param>
<param><key>num_items</key><value>12</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>1115</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0_0</value></param>
<param><key>istunflag</key><value>True</value></param>
<param><key>ifn</key><value>tun0</value></param>
<param><key>mtu</key><value>mtu-2</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_1</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>ccsds_decapsulate_net</key>
<param><key>id</key><value>ccsds_decapsulate_net_0</value></param>
<param><key>disaggregate</key><value>False</value></param>
<param><key>mtu</key><value>1115</value></param>
<param><key>pad_byte</key><value>0x7E</value></param>
</block>
<block>
<key>ccsds_ccsds_decoder</key>
<param><key>id</key><value>ccsds_decoder</value></param>
<param><key>deinterleave</key><value>True</value></param>
<param><key>descramble</key><value>True</value></param>
<param><key>printing</key><value>False</value></param>
<param><key>rs_decode</key><value>True</value></param>
<param><key>threshold</key><value>4</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>ccsds_diff_decoder</key>
<param><key>id</key><value>ccsds_diff_decoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>ccsds_diff_encoder</key>
<param><key>id</key><value>ccsds_diff_encoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>ccsds_encapsulate_net</key>
<param><key>id</key><value>ccsds_encapsulate_net_0</value></param>
<param><key>aggregate</key><value>False</value></param>
<param><key>mtu</key><value>1115</value></param>
<param><key>pad_byte</key><value>0x7E</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>ccsds_ccsds_encoder</key>
<param><key>id</key><value>ccsds_encoder</value></param>
<param><key>asm_tail</key><value>True</value></param>
<param><key>idle_block_time</key><value>50</value></param>
<param><key>idle</key><value>False</value></param>
<param><key>type</key><value>message</value></param>
<param><key>interleave</key><value>True</value></param>
<param><key>len_tag_key</key><value>""</value></param>
<param><key>printing</key><value>False</value></param>
<param><key>rs_encode</key><value>True</value></param>
<param><key>scramble</key><value>True</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>ccsds_insert_idle_frame</key>
<param><key>id</key><value>ccsds_insert_idle_frame_0</value></param>
<param><key>modulated_vector</key><value>modulated_idle_frame_trimmed_nodiff</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>mu</key><value>eq_gain</value></param>
<param><key>modulus</key><value>1</value></param>
<param><key>num_taps</key><value>15</value></param>
<param><key>sps</key><value>2</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>constel</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>eb</value></param>
<param><key>maxoutbuf</key><value>mtu</value></param>
<param><key>samples_per_symbol</key><value>sps_tx</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0</value></param>
<param><key>constellation</key><value>constel</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sps</key><value>sps_rx</value></param>
<param><key>symbols</key><value>modulated_sync_word</value></param>
<param><key>mark_delay</key><value>len(modulated_sync_word)-1-sps_tx/2</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0_0_0</value></param>
<param><key>sps</key><value>1</value></param>
<param><key>symbols</key><value>corr_sequence_nodiff</value></param>
<param><key>mark_delay</key><value>len(corr_sequence)-1</value></param>
<param><key>threshold</key><value>0.985</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>phase_bw</value></param>
<param><key>order</key><value>arity</value></param>
<param><key>use_snr</key><value>True</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0</value></param>
<param><key>comment</key><value>Resolves 90 deg ambiguity.  
Applies phase offset recovered 
by corr est block.  Don't try 
doing this before PFB CS</value></param>
<param><key>w</key><value>phase_bw*0</value></param>
<param><key>order</key><value>arity</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_0</value></param>
<param><key>rolloff</key><value>eb</value></param>
<param><key>w</key><value>phase_bw</value></param>
<param><key>filter_size</key><value>55</value></param>
<param><key>samps_per_sym</key><value>sps_rx</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>phase_bw</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>2</value></param>
<param><key>sps</key><value>sps_rx</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>eq_gain</value></param>
<param><key>label</key><value>Equalizer Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.01</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0</value></param>
<param><key>decoder_list</key><value>decoder_variable</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>fec_extended_encoder</key>
<param><key>id</key><value>fec_extended_encoder_0</value></param>
<param><key>encoder_list</key><value>encoder_variable</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_prefix</value></param>
<param><key>label</key><value>File Prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>expanduser('~')</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>he2pi_file_zeropad_source</key>
<param><key>id</key><value>he2pi_file_zeropad_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_prefix + "/Downloads/shakespeare.txt"</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>slp</key><value>1000</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>zeropad</key><value>int(samp_rate_tx)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>idle_block_time</value></param>
<param><key>label</key><value>Idle Block Time (ms)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_home</value></param>
<param><key>import</key><value>from os.path import expanduser</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_pi</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mtu</value></param>
<param><key>label</key><value>MTU</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1115</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phase_bw</value></param>
<param><key>label</key><value>Phase Bandwidth</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>6.28/100.0*0+0.05</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_rx</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label1</key><value>Received</value></param>
<param><key>label2</key><value>Post FLL BE</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>user_data_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"Rx Phase"</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>"|Correlation|^2"</value></param>
<param><key>name</key><value>"Correlation Outputs"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024*4</value></param>
<param><key>srate</key><value>samp_rate_tx</value></param>
<param><key>tr_delay</key><value>0.0005</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"corr_start"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"Rx Phase"</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>"|Correlation|^2"</value></param>
<param><key>name</key><value>"Correlation Outputs"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024*4</value></param>
<param><key>srate</key><value>samp_rate_tx</value></param>
<param><key>tr_delay</key><value>0.0005</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"corr_start"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>RX Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>415e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.999</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>label</key><value>TX Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>400e6</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(tx_freq, data_rate*2*0+1e6)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_tx</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>tx_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_tx</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_args</key><value>peak=0.7</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(rx_freq, samp_rate_rx*2)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>rx_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>user_data_rate</value></param>
<param><key>label</key><value>User Data Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.25e6*0+125e3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>tun_source</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>tun_source</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0_0_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>ccsds_insert_idle_frame_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_1</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>ccsds_encoder</sink_block_id><source_key>0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>digital_corr_est_cc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_0_0</source_block_id><sink_block_id>ccsds_encapsulate_net_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_1</source_block_id><sink_block_id>ccsds_diff_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_decapsulate_net_0</source_block_id><sink_block_id>blocks_tuntap_pdu_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ccsds_decoder</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ccsds_decoder</source_block_id><sink_block_id>ccsds_decapsulate_net_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_diff_decoder_0</source_block_id><sink_block_id>ccsds_decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_diff_encoder_0</source_block_id><sink_block_id>fec_extended_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_encapsulate_net_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_encoder</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_insert_idle_frame_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0</source_block_id><sink_block_id>fec_extended_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_arg_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0_0</source_block_id><sink_block_id>blocks_complex_to_arg_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>ccsds_diff_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_0</source_block_id><sink_block_id>blocks_skiphead_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>he2pi_file_zeropad_source_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>digital_fll_band_edge_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>ccsds_encoder</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
