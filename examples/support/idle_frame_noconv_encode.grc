<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>concatenated_qpsk_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_rs_idle_frame</value></param>
<param><key>value</key><value>(29L, 166L, 101L, 78L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_rs_idle_frame_nodiff</value></param>
<param><key>value</key><value>(26L, 207L, 252L, 29L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L, 255L, 72L, 14L, 192L, 154L, 13L, 112L, 188L, 142L, 44L, 147L, 173L, 167L, 183L, 70L, 206L, 90L, 151L, 125L, 204L, 50L, 162L, 191L, 62L, 10L, 16L, 241L, 136L, 148L, 205L, 234L, 177L, 254L, 144L, 29L, 129L, 52L, 26L, 225L, 121L, 28L, 89L, 39L, 91L, 79L, 110L, 141L, 156L, 181L, 46L, 251L, 152L, 101L, 69L, 126L, 124L, 20L, 33L, 227L, 17L, 41L, 155L, 213L, 99L, 253L, 32L, 59L, 2L, 104L, 53L, 194L, 242L, 56L, 178L, 78L, 182L, 158L, 221L, 27L, 57L, 106L, 93L, 247L, 48L, 202L, 138L, 252L, 248L, 40L, 67L, 198L, 34L, 83L, 55L, 170L, 199L, 250L, 64L, 118L, 4L, 208L, 107L, 133L, 228L, 113L, 100L, 157L, 109L, 61L, 186L, 54L, 114L, 212L, 187L, 238L, 97L, 149L, 21L, 249L, 240L, 80L, 135L, 140L, 68L, 166L, 111L, 85L, 143L, 244L, 128L, 236L, 9L, 160L, 215L, 11L, 200L, 226L, 201L, 58L, 218L, 123L, 116L, 108L, 229L, 169L, 119L, 220L, 195L, 42L, 43L, 243L, 224L, 161L, 15L, 24L, 137L, 76L, 222L, 171L, 31L, 233L, 1L, 216L, 19L, 65L, 174L, 23L, 145L, 197L, 146L, 117L, 180L, 246L, 232L, 217L, 203L, 82L, 239L, 185L, 134L, 84L, 87L, 231L, 193L, 66L, 30L, 49L, 18L, 153L, 189L, 86L, 63L, 210L, 3L, 176L, 38L, 131L, 92L, 47L, 35L, 139L, 36L, 235L, 105L, 237L, 209L, 179L, 150L, 165L, 223L, 115L, 12L, 168L, 175L, 207L, 130L, 132L, 60L, 98L, 37L, 51L, 122L, 172L, 127L, 164L, 7L, 96L, 77L, 6L, 184L, 94L, 71L, 22L, 73L, 214L, 211L, 219L, 163L, 103L, 45L, 75L, 190L, 230L, 25L, 81L, 95L, 159L, 5L, 8L, 120L, 196L, 74L, 102L, 245L, 88L)</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>encoder_variable</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>comment</key><value>Polynomials are often provided in octal.  
The blocks generally take decimals, though.
For example (171,133) =&gt; (121,91)</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[0133,0171]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length</value></param>
<param><key>value</key><value>4+(223+32)*5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32e3</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>block_id</key><value>blocks_probe_signal_vx_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.5</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>variable_qtgui_entry_0</value></param>
<param><key>value</key><value>variable_function_probe_0</value></param>
<param><key>label</key><value>Blah</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>blocks_probe_signal_vx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>length</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>223*5</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>length</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_1</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>length</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>223*5*[0x00]</value></param>
</block>
<block>
<key>ccsds_diff_encoder</key>
<param><key>id</key><value>ccsds_diff_encoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>ccsds_ccsds_encoder</key>
<param><key>id</key><value>ccsds_encoder</value></param>
<param><key>asm_tail</key><value>False</value></param>
<param><key>idle_block_time</key><value>50</value></param>
<param><key>idle</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>interleave</key><value>True</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>printing</key><value>False</value></param>
<param><key>rs_encode</key><value>True</value></param>
<param><key>scramble</key><value>True</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>fec_extended_encoder</key>
<param><key>id</key><value>fec_extended_encoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>encoder_list</key><value>encoder_variable</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_prefix</value></param>
<param><key>label</key><value>File Prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>expanduser('~')</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_home</value></param>
<param><key>import</key><value>from os.path import expanduser</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>color1</key><value>2</value></param>
<param><key>ncols</key><value>32*2*4</value></param>
<param><key>nrows</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>32*2*4</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>ccsds_encoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_probe_signal_vx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_vector_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_1</source_block_id><sink_block_id>ccsds_diff_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_diff_encoder_0</source_block_id><sink_block_id>fec_extended_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_encoder</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
