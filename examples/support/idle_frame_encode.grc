<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>concatenated_qpsk_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame</value></param>
<param><key>value</key><value>encoded_concat_idle_frame_raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame_nodiff</value></param>
<param><key>value</key><value>encoded_concat_idle_frame_nodiff_raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame_nodiff_raw</value></param>
<param><key>value</key><value>(206L, 63L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 111L, 93L, 73L, 194L, 79L, 242L, 104L, 107L)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame_raw</value></param>
<param><key>value</key><value>(31L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 216L, 195L, 47L, 110L, 243L, 228L, 181L, 79L, 29L, 152L, 28L, 218L, 254L, 27L, 236L, 65L, 157L, 23L, 81L, 250L, 82L, 133L, 132L, 198L, 36L, 229L, 247L, 173L, 220L, 138L, 70L, 171L, 168L, 215L, 1L, 66L, 226L, 193L, 18L, 90L, 113L, 86L, 204L, 237L, 3L, 127L, 214L, 67L, 160L, 35L, 211L, 72L, 43L, 39L, 154L, 33L, 238L, 124L, 169L, 149L, 227L, 131L, 240L, 155L, 99L, 12L, 189L, 187L, 207L, 146L, 213L, 60L, 118L, 96L, 115L, 107L, 248L, 111L, 177L, 6L, 116L, 93L, 71L, 233L, 74L, 22L, 19L, 24L, 147L, 151L, 222L, 183L, 114L, 41L, 26L, 174L, 163L, 92L, 5L, 11L, 139L, 4L, 73L, 105L, 197L, 91L, 51L, 180L, 13L, 255L, 89L, 14L, 128L, 143L, 77L, 32L, 172L, 158L, 104L, 135L, 185L, 242L, 166L, 87L, 142L, 15L, 194L, 109L, 140L, 50L, 246L, 239L, 62L, 75L, 84L, 241L, 217L, 129L, 205L, 175L, 225L, 190L, 196L, 25L, 209L, 117L, 31L, 165L, 40L, 88L, 76L, 98L, 78L, 95L, 122L, 221L, 200L, 164L, 106L, 186L, 141L, 112L, 20L, 46L, 44L, 17L, 37L, 167L, 21L, 108L, 206L, 208L, 55L, 253L, 100L, 58L, 2L, 61L, 52L, 130L, 178L, 121L, 162L, 30L, 231L, 202L, 153L, 94L, 56L, 63L, 9L, 182L, 48L, 203L, 219L, 188L, 249L, 45L, 83L, 199L, 102L, 7L, 54L, 191L, 134L, 251L, 16L, 103L, 69L, 212L, 126L, 148L, 161L, 97L, 49L, 137L, 57L, 125L, 235L, 119L, 34L, 145L, 170L, 234L, 53L, 192L, 80L, 184L, 176L, 68L, 150L, 156L, 85L, 179L, 59L, 64L, 223L, 245L, 144L, 232L, 8L, 244L, 210L, 10L, 201L, 230L, 136L, 123L, 159L, 42L, 101L, 120L, 224L, 252L, 38L, 15L, 167L, 58L, 100L, 15L, 2L, 76L, 161L)</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>encoder_variable</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>comment</key><value>Polynomials are often provided in octal.  
The blocks generally take decimals, though.
For example (171,133) =&gt; (121,91)</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>1279*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[epy_tools.reverse_bits(0171), epy_tools.reverse_bits(0133)]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length</value></param>
<param><key>value</key><value>((223+32)*5+4)*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>same</value></param>
<param><key>value</key><value>encoded_concat_idle_frame == encoded_concat_idle_frame_nodiff</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32e3</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>block_id</key><value>blocks_probe_signal_vx_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.5</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_0</value></param>
<param><key>block_id</key><value>blocks_probe_signal_vx_0_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.5</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>variable_qtgui_entry_0</value></param>
<param><key>value</key><value>variable_function_probe_0</value></param>
<param><key>label</key><value>Conv Frame</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>variable_qtgui_entry_0_0</value></param>
<param><key>value</key><value>variable_function_probe_0_0</value></param>
<param><key>label</key><value>RS Frame</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>length</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>4+255*5+4+255*5+4</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>length/2</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>blocks_probe_signal_vx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>length</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>blocks_probe_signal_vx_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>length/2</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>comment</key><value>Skip the first ASM, Data Block and Trailing ASM</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>(4+255*5+4)*0 + 4</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_1</value></param>
<param><key>num_items</key><value>length/2</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_1_0</value></param>
<param><key>comment</key><value>Skip the first fill data + ASM
Second round should be 
predicatble</value></param>
<param><key>num_items</key><value>length*8</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_1_0_0</value></param>
<param><key>comment</key><value>Skip the first fill data + ASM
Second round should be 
predicatble</value></param>
<param><key>num_items</key><value>length*8-(32*2*8)</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>223*5</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>length</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>length/2</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_1</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>length</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>length/2</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>223*5*[0x00]</value></param>
</block>
<block>
<key>ccsds_diff_encoder</key>
<param><key>id</key><value>ccsds_diff_encoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>ccsds_ccsds_encoder</key>
<param><key>id</key><value>ccsds_encoder</value></param>
<param><key>asm_tail</key><value>True</value></param>
<param><key>idle_block_time</key><value>50</value></param>
<param><key>idle</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>interleave</key><value>True</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>printing</key><value>False</value></param>
<param><key>rs_encode</key><value>True</value></param>
<param><key>scramble</key><value>True</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>epy_tools</value></param>
<param><key>source_code</key><value>
def reverse_bits(x):
    return int(bin(x)[2:][::-1], base=2)

</value></param>
</block>
<block>
<key>fec_extended_encoder</key>
<param><key>id</key><value>fec_extended_encoder_0</value></param>
<param><key>encoder_list</key><value>encoder_variable</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_prefix</value></param>
<param><key>label</key><value>File Prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>expanduser('~')</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_home</value></param>
<param><key>import</key><value>from os.path import expanduser</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>color1</key><value>2</value></param>
<param><key>ncols</key><value>32*2*4</value></param>
<param><key>nrows</key><value>1</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>32*2*8</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0_0</source_block_id><sink_block_id>blocks_skiphead_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_1</source_block_id><sink_block_id>blocks_head_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_1_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_1_0</source_block_id><sink_block_id>blocks_skiphead_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_1_0_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>ccsds_encoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_probe_signal_vx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_vector_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_probe_signal_vx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_vector_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_1</source_block_id><sink_block_id>ccsds_diff_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_diff_encoder_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_diff_encoder_0</source_block_id><sink_block_id>fec_extended_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_encoder</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_0</source_block_id><sink_block_id>blocks_skiphead_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
