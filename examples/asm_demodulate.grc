<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R</value></param>
<param><key>value</key><value>1/2.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>2**constel.bits_per_symbol()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>constel.bits_per_symbol()</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>corr_sequence</value></param>
<param><key>value</key><value>((-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>corr_sequence_nodiff</value></param>
<param><key>value</key><value>((0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (-0.7071070075035095+0.7071070075035095j), (-0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095-0.7071070075035095j), (0.7071070075035095+0.7071070075035095j))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>user_data_rate/R</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate_sps</value></param>
<param><key>value</key><value>data_rate/bps</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>decoder_variable</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[0133,0171]</value></param>
<param><key>rate</key><value>int(1/R)</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.35*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>enc_sync_word_len</value></param>
<param><key>value</key><value>len(encoded_sync_word_nodiff)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame</value></param>
<param><key>value</key><value>encoded_concat_idle_frame_raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame_nodiff</value></param>
<param><key>value</key><value>encoded_concat_idle_frame_nodiff_raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame_nodiff_raw</value></param>
<param><key>value</key><value>(2L, 63L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 175L, 98L, 74L, 61L, 79L, 242L, 152L, 87L)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_concat_idle_frame_raw</value></param>
<param><key>value</key><value>(32L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 215L, 60L, 220L, 98L, 243L, 235L, 122L, 79L, 17L, 164L, 220L, 213L, 205L, 235L, 224L, 190L, 145L, 24L, 145L, 53L, 94L, 181L, 120L, 9L, 24L, 38L, 11L, 94L, 47L, 137L, 137L, 164L, 107L, 235L, 205L, 113L, 17L, 62L, 45L, 85L, 113L, 166L, 0L, 45L, 207L, 128L, 38L, 188L, 96L, 47L, 19L, 120L, 36L, 215L, 166L, 45L, 226L, 79L, 166L, 154L, 220L, 79L, 60L, 107L, 92L, 243L, 113L, 139L, 207L, 173L, 233L, 60L, 70L, 147L, 115L, 87L, 55L, 175L, 130L, 250L, 68L, 98L, 68L, 213L, 122L, 213L, 224L, 36L, 96L, 152L, 45L, 120L, 190L, 38L, 38L, 145L, 175L, 175L, 53L, 196L, 68L, 248L, 181L, 85L, 198L, 152L, 0L, 183L, 62L, 0L, 154L, 241L, 128L, 188L, 77L, 224L, 147L, 94L, 152L, 183L, 137L, 62L, 154L, 107L, 113L, 60L, 241L, 173L, 115L, 205L, 198L, 47L, 62L, 183L, 164L, 241L, 26L, 77L, 205L, 92L, 222L, 190L, 11L, 233L, 17L, 137L, 19L, 85L, 235L, 87L, 128L, 145L, 130L, 96L, 181L, 226L, 248L, 152L, 154L, 70L, 190L, 188L, 215L, 17L, 19L, 226L, 213L, 87L, 26L, 96L, 2L, 220L, 248L, 2L, 107L, 198L, 2L, 241L, 55L, 130L, 77L, 122L, 98L, 222L, 36L, 250L, 105L, 173L, 196L, 243L, 198L, 181L, 207L, 55L, 24L, 188L, 250L, 222L, 147L, 196L, 105L, 55L, 53L, 115L, 122L, 248L, 47L, 164L, 70L, 36L, 77L, 87L, 173L, 94L, 2L, 70L, 9L, 130L, 215L, 139L, 226L, 98L, 105L, 26L, 250L, 243L, 92L, 68L, 79L, 139L, 85L, 92L, 105L, 128L, 11L, 115L, 224L, 9L, 175L, 24L, 11L, 196L, 222L, 9L, 53L, 233L, 139L, 120L, 147L, 233L, 166L, 183L, 19L, 207L, 26L, 15L, 155L, 245L, 107L, 240L, 253L, 76L, 158L)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_sync_word</value></param>
<param><key>value</key><value>[57L, 167L, 60L, 49L, 128L, 82L]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>encoded_sync_word_nodiff</value></param>
<param><key>value</key><value>(74L, 61L, 79L, 242L, 152L, 87L)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>eq_gain</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>label</key><value>Equalizer: rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>idle_frame_shift</value></param>
<param><key>comment</key><value>24 seems to be the magic shift
More and score is unchanged
Less and it goes down.</value></param>
<param><key>value</key><value>24-4+4</value></param>
<param><key>gui_hint</key><value>6,0,1,2</value></param>
<param><key>label</key><value>Idle Frame Shift</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-len(sync_word)*16</value></param>
<param><key>step</key><value>2</value></param>
<param><key>stop</key><value>len(sync_word)*16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_mod_vec</value></param>
<param><key>value</key><value>len(modulated_idle_frame_trimmed_nodiff)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_idle_frame_trimmed</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed[i] for i in range(len(pad)*8+idle_frame_shift, len(pad)*8+enc_sync_word_len*8+idle_frame_shift)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_idle_frame_trimmed_nodiff</value></param>
<param><key>value</key><value>[modulated_preamble_untrimmed_nodiff[i] for i in range(len(pad)*8+idle_frame_shift, len(pad)*8+enc_sync_word_len*8+idle_frame_shift)]</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed</value></param>
<param><key>comment</key><value>Packed bytes get modulated.
Samples come out.
Since we're QPSK, you get
8*sps/bps out.</value></param>
<param><key>data</key><value>pad + list(encoded_sync_word) + pad</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_preamble_untrimmed_nodiff</value></param>
<param><key>data</key><value>pad + list(encoded_sync_word_nodiff) + pad</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>digital.generic_mod(constellation=constel,differential=False,samples_per_symbol=sps_tx,pre_diff_code=True,excess_bw=eb,verbose=False,log=False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pad</value></param>
<param><key>value</key><value>[0]*223*5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pad_len</value></param>
<param><key>value</key><value>len(pad)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_bw</value></param>
<param><key>value</key><value>2*pi/100.0*0+0.05</value></param>
<param><key>label</key><value>Phase: Bandwidth</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps_rx), eb, 11*sps_rx*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>value</key><value>data_rate*sps_rx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>value</key><value>data_rate*sps_tx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_rx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_tx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>value</key><value>[0x1a, 0xcf, 0xfc, 0x1d]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>user_data_rate</value></param>
<param><key>value</key><value>0.25e6*0+125e3*2</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>block_id</key><value>blocks_probe_signal_vx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.5</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_0</value></param>
<param><key>block_id</key><value>blocks_probe_signal_vx_0_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.5</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>variable_qtgui_entry_0</value></param>
<param><key>value</key><value>variable_function_probe_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Decoded Frame</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>variable_qtgui_entry_0_0</value></param>
<param><key>value</key><value>variable_function_probe_0_0</value></param>
<param><key>label</key><value>Conv  Encoded Frame</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>length*16*2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>1.0/pi</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>blocks_probe_signal_vx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>length</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>blocks_probe_signal_vx_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>length*2</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>length*3</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>length*2*3</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>length</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>length*2</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>propagate_tags</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>samp_rate_rx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate_rx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>length</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>length</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>modulated_preamble_untrimmed_nodiff</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>modulated_idle_frame_trimmed_nodiff</value></param>
</block>
<block>
<key>ccsds_ccsds_decoder</key>
<param><key>id</key><value>ccsds_decoder</value></param>
<param><key>deinterleave</key><value>True</value></param>
<param><key>descramble</key><value>True</value></param>
<param><key>printing</key><value>False</value></param>
<param><key>rs_decode</key><value>True</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>ccsds_diff_decoder</key>
<param><key>id</key><value>ccsds_diff_decoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>mu</key><value>eq_gain</value></param>
<param><key>modulus</key><value>1</value></param>
<param><key>num_taps</key><value>15</value></param>
<param><key>sps</key><value>2</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>constel</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0</value></param>
<param><key>comment</key><value>Outputs 2 floats for every 
1 symbol input for QPSK.</value></param>
<param><key>constellation</key><value>constel</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0_0</value></param>
<param><key>sps</key><value>1</value></param>
<param><key>symbols</key><value>corr_sequence_nodiff</value></param>
<param><key>mark_delay</key><value>len(corr_sequence)</value></param>
<param><key>threshold</key><value>0.985*0+0.985</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_bb</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0_0_0</value></param>
<param><key>access_code</key><value>''.join([bin(x)[2:].zfill(8) for x in sync_word])[64-48:]</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>phase_bw</value></param>
<param><key>order</key><value>arity</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0</value></param>
<param><key>w</key><value>phase_bw*0.1*0</value></param>
<param><key>order</key><value>arity</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/100.0*0+phase_bw</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>2</value></param>
<param><key>sps</key><value>sps_rx</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0</value></param>
<param><key>decoder_list</key><value>decoder_variable</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_pi</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>style1</key><value>1</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1279*16/8*2</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>(length-4)*8</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>0</value></param>
<param><key>size</key><value>len(modulated_preamble_untrimmed_nodiff)</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0_1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>0</value></param>
<param><key>size</key><value>len(modulated_idle_frame_trimmed_nodiff)</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>name</key><value>"Laddy Frick'n Dah"</value></param>
<param><key>size</key><value>64*10</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"Rx Phase"</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>"|Correlation|^2"</value></param>
<param><key>name</key><value>"Correlation Outputs"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024*4</value></param>
<param><key>srate</key><value>samp_rate_tx</value></param>
<param><key>tr_delay</key><value>0.0005</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"corr_start"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1000</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_0_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"Rx Phase"</value></param>
<param><key>name</key><value>"Correlation Outputs"</value></param>
<param><key>size</key><value>len(modulated_idle_frame_trimmed_nodiff)/bps</value></param>
<param><key>srate</key><value>samp_rate_tx</value></param>
<param><key>tr_delay</key><value>0.0005</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_tag</key><value>"corr_start"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>ymax</key><value>1000</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>sync_to_pdu</key>
<param><key>id</key><value>sync_to_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>packlen</key><value>1279*8</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>sync</key><value>''.join([bin(x)[2:].zfill(8) for x in sync_word])</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_1</source_block_id><sink_block_id>blocks_throttle_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0_0</source_block_id><sink_block_id>blocks_skiphead_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_1</source_block_id><sink_block_id>blocks_char_to_float_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>blocks_pack_k_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_probe_signal_vx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_vector_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_probe_signal_vx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_vector_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>sync_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_0_1_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_head_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_decoder</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ccsds_diff_decoder_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_diff_decoder_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_diff_decoder_0</source_block_id><sink_block_id>ccsds_decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0</source_block_id><sink_block_id>fec_extended_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_arg_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_corr_est_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>ccsds_diff_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_to_pdu_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
